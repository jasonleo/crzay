# Keil uVision project crazy.uvproj, settings and files
target crazy (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: crazy +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\common;..\core;..\core;..\drive\flash;..\drive\hmc;..\drive\led;..\drive\motor;..\drive\mpu;..\drive\pid;..\drive\power;..\drive\timer;..\drive\uart;..\drive\wireless;..\drive;..\include;..\main;..\system;..\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group common
    ../common/: delay.c sys.c usart.c
  group core
    ../core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group drive
    ../drive/hmc/: hmc5883l.c
    ../drive/led/: led.c
    ../drive/motor/: motor.c
    ../drive/mpu/: dmp.c mpu6050.c
    ../drive/pid/: Control.c
    ../drive/power/: battery.c
    ../drive/timer/: timer.c
    ../drive/wireless/: bt.c nrf24l01.c revedata.c
    ../drive/: i2c.c spi.c stmflash.c
  group lib
    ../lib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c
  group main
    ../main/: main.c
  group sysytem
    ../system/: sys_fun.c
